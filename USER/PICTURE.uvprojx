# Keil uVision project PICTURE.uvprojx, settings and files
target PICTURE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: PICTURE +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\PICTURE;..\FWLIB\inc;..\HARDWARE\24CXX;..\HARDWARE\BEEP;..\HARDWARE\DHT11;..\HARDWARE\EXTI;..\HARDWARE\GPS;..\HARDWARE\I2S;..\HARDWARE\IIC;..\HARDWARE\RAIN;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\GUI\lvgl-8.0.2;..\GUI\lvgl-8.0.2\src;..\GUI\lvgl-8.0.2\examples;..\HARDWARE\IWDG;..\HARDWARE\USART2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/RAIN/: rain.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/IWDG/: iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_iwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group README
    ../: readme.txt
  group GUI
    ../GUI/lvgl-8.0.2/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl-8.0.2/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../GUI/lvgl-8.0.2/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl-8.0.2/src/extra/: lv_extra.c
    ../GUI/lvgl-8.0.2/src/extra/layouts/flex/: lv_flex.c
    ../GUI/lvgl-8.0.2/src/extra/layouts/grid/: lv_grid.c
    ../GUI/lvgl-8.0.2/src/extra/themes/basic/: lv_theme_basic.c
    ../GUI/lvgl-8.0.2/src/extra/themes/default/: lv_theme_default.c
    ../GUI/lvgl-8.0.2/src/extra/themes/mono/: lv_theme_mono.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/animimg/: lv_animimg.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/chart/: lv_chart.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/keyboard/: lv_keyboard.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/led/: lv_led.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/list/: lv_list.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/meter/: lv_meter.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/msgbox/: lv_msgbox.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/span/: lv_span.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/spinbox/: lv_spinbox.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/spinner/: lv_spinner.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/tabview/: lv_tabview.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/tileview/: lv_tileview.c
    ../GUI/lvgl-8.0.2/src/extra/widgets/win/: lv_win.c
    ../GUI/lvgl-8.0.2/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../GUI/lvgl-8.0.2/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../GUI/lvgl-8.0.2/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../GUI/lvgl-8.0.2/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
